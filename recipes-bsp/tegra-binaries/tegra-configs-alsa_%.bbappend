
COMPATIBLE_MACHINE = "jasmine"

RDEPENDS:${PN}:append:jasmine = " tegra-configs-alsa-init"
